# Keil uVision project SSP0-SD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SSP0-SD-dma
  c flags: OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s main.c
  group New Group
    ./LIBS/: AsciiLib.c fat32.c File_Config.c gpio.c sdcard.c spi.c system_LPC17xx.c Timing.c
    ./: i2c.c uda1380.c RDB1768_AUDIO.c
